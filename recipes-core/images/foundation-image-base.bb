include recipes-core/images/core-image-base.bb

IMAGE_INSTALL_append = " dtr-dev"
